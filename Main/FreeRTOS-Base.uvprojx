# Keil uVision project FreeRTOS-Base.uvprojx, settings and files
target FreeRTOS-Base (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Tuya +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --diag_suppress=550,111,177
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3;..\Tuya;..\Config\config;..\Config\wifi_usart;..\Driver\key;..\Main;..\Config\key_gpio;..\Driver\buzzer;..\Config\device_gpio;..\Driver\sensor_DHT20;..\Config\DHT20_i2c;..\Driver\sensor_JW01;..\Config\JW01_usart;..\Driver\device;.\Mode;..\SYSTEM\timer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Main
    ./: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h type_def.h
    ./Mode/: mode.c mode_task.c
    ./AutoRun/: AutoRun.c
    ./TimeHeat/: TimeHeat.c
    ./PirDetect/: PirDetect.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: timer.c
  group Tuya
    ../Tuya/: mcu_api.c protocol.c system.c tuya_wifi_usart.c
  group Config
    ../Config/config/: config.c
    ../Config/wifi_usart/: wifi_usart.c
    ../Config/key_gpio/: key_gpio.c
    ../Config/device_gpio/: device_gpio.c
    ../Config/DHT20_i2c/: DHT20_i2c.c
    ../Config/JW01_usart/: JW01_usart.c
  group Driver
    ../Driver/key/: key.c
    ../Driver/buzzer/: buzzer.c
    ../Driver/sensor_DHT20/: sensor_DHT20.c
    ../Driver/sensor_JW01/: sensor_JW01.c
    ../Driver/device/: device.c
